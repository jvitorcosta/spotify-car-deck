#include "icon_map.h"
#include <cctype>
#include <cstring>

namespace icons {

static const char* const ART[][SIZE] = {
    {   // Phone
        "...######...", "..#......#..", "..#.####.#..", "..#.#..#.#..",
        "..#.#..#.#..", "..#.#..#.#..", "..#.#..#.#..", "..#.####.#..",
        "..#......#..", "..#..##..#..", "..#......#..", "...######...",
    },
    {   // Laptop
        "............", ".##########.", ".#........#.", ".#........#.",
        ".#........#.", ".#........#.", ".#........#.", ".##########.",
        "############", "#..........#", "############", "............",
    },
    {   // Speaker
        "..########..", "..#......#..", "..#..##..#..", "..#..##..#..",
        "..#......#..", "..#.####.#..", "..##....##..", "..#......#..",
        "..##....##..", "..#.####.#..", "..#......#..", "..########..",
    },
    {   // Tv
        "...#....#...", "....#..#....", ".....##.....", "############",
        "#..........#", "#..........#", "#..........#", "#..........#",
        "#..........#", "############", "..#......#..", "............",
    },
    {   // Car
        "............", "............", "...######...", "..#..#...#..",
        ".#...#....#.", "############", "#..........#", "#.##....##.#",
        "############", "..##....##..", "............", "............",
    },
    {   // Shuffle (crossing arrows)
        "............", "............", "..........#.", "###....#####",
        "...#..#...#.", "....##......", "....##......", "...#..#...#.",
        "###....#####", "..........#.", "............", "............",
    },
    {   // Repeat (loop with arrow heads)
        "............", "........#...", ".#########..", "#.......#...",
        "#...........", "#..........#", "#..........#", "...........#",
        "...#.......#", "..#########.", "...#........", "............",
    },
    {   // Note (eighth note)
        "......###...", "......####..", "......#..##.", "......#...#.",
        "......#.....", "......#.....", "......#.....", "..#####.....",
        ".######.....", ".######.....", "..####......", "............",
    },
};

static bool eq(const char* a, const char* b) {
    for (; *a && *b; ++a, ++b)
        if (tolower((unsigned char)*a) != tolower((unsigned char)*b)) return false;
    return *a == *b;
}

Icon forDevice(const char* t) {
    if (!t || !t[0]) return Icon::Speaker;
    if (eq(t, "Smartphone") || eq(t, "Tablet")) return Icon::Phone;
    if (eq(t, "Computer")) return Icon::Laptop;
    if (eq(t, "TV") || eq(t, "CastVideo") || eq(t, "STB") || eq(t, "GameConsole")) return Icon::Tv;
    if (eq(t, "Automobile")) return Icon::Car;
    return Icon::Speaker;   // Speaker, AVR, CastAudio, AudioDongle, Unknown, ...
}

const char* row(Icon i, int y) {
    if (y < 0 || y >= SIZE) return nullptr;
    return ART[(int)i][y];
}

bool pixel(Icon i, int x, int y) {
    const char* r = row(i, y);
    return r && x >= 0 && x < SIZE && r[x] == '#';
}

}
